	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R2,=NUM
	LDR R3,[R2]
	LDR R0,=SRC
	LDR R4,=5
UP	
	LDR R1,[R0]
	CMP R1,R3
	BEQ FND
	ADD R0,#4
	SUBS R4,#1
	BNE UP
FND	LDR R8,=DST
	STR R0,[R8]		
STOP B STOP
SRC DCD 0X12345678,0X11111111,0X22222222,0X33333333,0X44444444	
NUM DCD 0X22222222
	AREA mydata, DATA,READWRITE
DST	DCD 0
	END