	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R6,=DST
	LDR R3,=0
	LDR R7,=0
	LDR R4,=4
	LDR R0,=SRC
AGAIN
	SUB R4,R7
	LDR R0,=SRC
	ADD R0,R3
	LDR R1,[R0]
	MOV R10,R1
	
UP	ADD R0,#4
	LDR R2,[R0]
	CMP R2,R1
	BCS HERE
	MOV R5,R2
	MOV R2,R1
	MOV R1,R5
	MOV R8,R0
	;MOV R9,R2
HERE
	SUBS R4,#1
	BNE UP
	LDR R9,[R8]
	STR R10,[R8]
	LDR R0,=SRC
	ADD R0,R3
	STR R9,[R0]
	ADD R6,#04
	ADD R3,#4
	ADD R7,#1
	MOV R4,#4
	CMP R4,R7
	BNE AGAIN
STOP B STOP

	AREA mydata, DATA,READWRITE
SRC DCD 0X22222222,0X44444444,0X11111111,0X88888888,0X00000000
DST DCD 0
	END