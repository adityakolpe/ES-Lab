	AREA RESET ,  DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0X10001000
	DCD Reset_Handler
	ALIGN
	
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler

Reset_Handler
	MOV R4,#0
	MOV R0,#0X05
	BL FACT

STOP B STOP

FACT PUSH {R4,R14}
	MOV R4,R0
	CMP R0, #0
	BNE NONZERO
	MOV R0,#1
	B LAST
NONZERO
	SUB R0,R0,#1
	BL FACT 
	MUL R0,R0,R4
LAST
	POP {R4,R14}
	BX LR
	
	AREA mydata, DATA, READWRITE
DST DCD 0
	END