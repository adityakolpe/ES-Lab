	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=NUM1
	LDR R1,=NUM2
	
	LDR R2,[R0]
	LDR R3,[R1]
	
	CMP R2,#0X41
	BCC H1
	SUB R2,#7
H1	
	SUB R2,#0X30
	MOV R4,R2
	LSL R4,#4
	
	CMP R3,#0X41
	BCC H2
	SUB R3,#7
H2
	SUB R3,#0X30
	ORR R4,R3
STOP B STOP
NUM1 DCD 0X31
NUM2 DCD 0X45	
	AREA mydata, DATA,READWRITE
DST
	DCD 0
	END