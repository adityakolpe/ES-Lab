	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R1,=0X0A
	MOV R4,#0
	MOV R2,#0
	LDR R3,=NUM
	LDR R0,[R3]
	MOV R1,#0X0A
UP
	BL DIV
UP3	ORR R4,R0
	ROR R4,#4
	MOV R0,R2
	CMP R0,R1
	BCS UP
	ORR R4, R2
	ROR R4, #20
STOP B STOP

DIV CMP R0,R1
	BCC UP3
	MOV R2,#0
UP2	SUB R0,R1
	ADD R2,#01
	CMP R1,R0
	BCC UP2
	BX LR 

NUM DCD 0X1F
	AREA mydata, DATA, READWRITE
DST DCD 0
	END