	AREA RESET, DATA, READONLY
	EXPORT __Vectors
__Vectors
	DCD 0x10001000
	DCD Reset_Handler
	
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0,=BCD
	MOV R1,#01
	LDR R5,[R0]
	MOV R4,#0X0A
UP	
	AND R2,R5,#0X0F
	MLA R3,R2,R1,R3
	MUL R1,R4
	LSR R5,#4
	CMP R5,#0
	BNE UP
STOP B STOP
BCD DCD 0X17
	AREA mydata, DATA, READWRITE
DST	DCD 0
	END